SRC_URI_azboxhd = "${GITHUB_URI}/oe-alliance/${BPN}.git"
SRC_URI_azboxme = "${GITHUB_URI}/oe-alliance/${BPN}.git"
SRC_URI_azboxminime = "${GITHUB_URI}/oe-alliance/${BPN}.git"
